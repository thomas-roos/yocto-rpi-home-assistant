# Set PYO3_USE_ABI3_FORWARD_COMPATIBILITY for Python 3.14+ compatibility
export PYO3_USE_ABI3_FORWARD_COMPATIBILITY = "1"
