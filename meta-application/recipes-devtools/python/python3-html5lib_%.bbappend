FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-ast.Str-compatibility-for-Python-3.14.patch"

