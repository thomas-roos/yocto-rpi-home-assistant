# Prefer newer version with Python 3.14 support
PREFERRED_VERSION_python3-orjson = "3.11.5"
