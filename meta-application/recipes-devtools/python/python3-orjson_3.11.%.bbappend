# Upgrade to 3.11.5 for Python 3.14 support
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
