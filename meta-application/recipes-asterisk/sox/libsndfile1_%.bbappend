# sox DEPENDS on libsndfile1; building sox-native therefore needs it native too.
BBCLASSEXTEND = "native nativesdk"
