# Part of the libsndfile1-native -> sox-native dependency chain needed to build
# asterisk-sounds-de. Upstream does not extend these to native.
BBCLASSEXTEND = "native nativesdk"
