# Disable file clash checking for Python namespace packages
ERROR_QA:remove = "installed-vs-shipped"
WARN_QA:remove = "installed-vs-shipped"
